## drivers/staging/rtl8723au_bt/Kconfig
```kconfig
config RTL8723AU_BT
	tristate "Realtek 8723B USB Bluetooth"
	depends on USB
	---help---
	  Help message of RTL8723AU_BT
```
